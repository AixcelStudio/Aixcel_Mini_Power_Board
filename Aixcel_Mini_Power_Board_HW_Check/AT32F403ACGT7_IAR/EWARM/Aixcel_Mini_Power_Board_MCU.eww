<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Aixcel_Mini_Power_Board_MCU.ewp</path>
  </project>
  <batchBuild/>
</workspace>


